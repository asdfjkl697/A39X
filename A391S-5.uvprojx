# Keil uVision project A391S-5.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: GD32F303VG GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: A391S-5 +hex
  AfterMake: C:\myself\keil\ARM 536\MDK\ARM\ARMCC\bin\fromelf.exe --i32 --output ./Objects/A391S-5.hex ./Objects/A391S-5.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F30X_XD
  c include: .\App;.\Firmware\GD32F30x_standard_peripheral\Include;.\Firmware\CMSIS\GD\GD32F30x\Include;.\USER;.\USER\Air;.\USER\Heat;.\USER\Motor;.\USER\LED;.\USER\NOI;.\USER\Voice;.\USER\WorkState;.\USER\Bluetooth;.\USER\ArmKey;.\USER\Power;.\USER\Leg;.\USER\485COM;.\USER\FootRoll&CalfKnead;.\USER\Handler;.\USER\Movement;.\USER\Action;.\USER\Pump;.\USER\Memory;.\USER\Health
  memory RVCT4: ROM 0x8004000 size 0x36000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group StartUp
    ./Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group CMSIS
    ./Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Firmware
    ./Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group App
    ./App/: gd32f30x_it.c main.c systick.c System.c
    ./USER/: SysCfg.h
  group User
    ./USER/: config.c ErrorCheck.c
  group Air
    ./USER/Air/: Air.c
  group Heat
    ./USER/Heat/: Heat.c
  group Motor
    ./USER/Motor/: Motor.c
  group LED
    ./USER/LED/: Led.c
  group NOI
    ./USER/NOI/: NOI.c
  group Voice
    ./USER/Voice/: Voice.c
  group Bluetooth
    ./USER/Bluetooth/: Bluetooth.c App.c
    ./USER/: flash_address.txt
  group Power
    ./USER/Power/: Power.c
  group Health
    ./USER/Health/: health.c health.h
  group ArmKey
    ./USER/ArmKey/: ArmKey.c
  group Leg
    ./USER/Leg/: Leg.c
  group Movement
    ./USER/Movement/: MoveUp.c MoveDw.c MoveLogic.c
  group WorkState
    ./USER/WorkState/: WorkState.c MassageInit.c
  group 485COM
    ./USER/485COM/: _485Com.c
  group FootRoll&CalfKnead
    ./USER/FootRoll&CalfKnead/: FootFlex.c CalfKnead.c
  group Action
    ./USER/Action/: AT.c Table.c
    ./USER/FootRoll&CalfKnead/: FootRoll.c
  group Handler
    ./USER/Handler/: Handler.c KeyFunc.c Display.c
  group Memory
    ./USER/Memory/: Memory.c
  group FMC
    ./USER/FMC/: fmc.c
software components: CMSIS:CORE 5.5.0
